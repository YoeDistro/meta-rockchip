inherit features_check

REQUIRED_DISTRO_FEATURES:append:rk-rauc-demo = " systemd rauc"
REQUIRED_MACHINE_FEATURES:append:rk-rauc-demo = " rk-u-boot-env"
