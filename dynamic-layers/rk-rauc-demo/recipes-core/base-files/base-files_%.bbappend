inherit rk-rauc-demo-features-check
FILESEXTRAPATHS:prepend:rk-rauc-demo := "${THISDIR}/files:"
