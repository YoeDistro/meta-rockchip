inherit rk-rauc-demo-features-check

PACKAGECONFIG:append:rk-rauc-demo = " repart openssl"
