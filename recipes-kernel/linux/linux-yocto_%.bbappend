require linux-rockchip.inc
